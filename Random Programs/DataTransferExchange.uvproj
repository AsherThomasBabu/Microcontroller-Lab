# Keil uVision project DataTransferExchange.uvproj, settings and files
target Target 1 (MCS-51)
  device: R8051 Cadence Design Systems Inc.
  cpu: IRAM(0-0x7F)  CLOCK(12000000) MODC2
  output: DataTransferExchange
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DataTransferExchange.a51 AddSub.a51 MulDiv.a51 SumOfSeries.a51 6-LargestSmallest.a51 7-Sorting.a51
